# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F502 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0xFFF) CLOCK(24000000)
  output: wtu +hex
  c flags: Optimize=8
  c include: .\inc
  group Source Group 1
    ./: STARTUP.A51
    ./src/: AD7176.c AdcDrv.c AngApp.c Calibration.c CalMcuT.c CmdSub.c Comm.c Delay.c Filter.c Flash.c Init.c main.c ModBusCrc.c ModBusRtu.c Send.c Sensor.c SPI.C Sub.c Timer.c Int0.c Key.c Key.h
