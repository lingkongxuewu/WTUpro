/*--------------------------------文*件*信*息-----------------------------
* 文件名：  Delay.c
* 版　本：  v1.0
* 描  述：  100T双轴 整合后的版本
* 创建人：   
* 日  期：   
--------------------------------------------------------------------------
*当前版本:	v1.0
*修 改 人:
*日　  期:
----------------------------------修改履历--------------------------------
1、
2、
3、
4、
------------------------------------------------------------------------*/
#include "_Include.h"

//***********************************************************************///***********************************************************************/
// *功    能：
// *入    口：
// *出    口：
// *备    注：
// *函数性质：
//***********************************************************************/

void delay_100us (void)
{	int16u i;
	for(i=45;i>0;i--){ ; }
}
//***********************************************************************/
void delay_ms_ (void)
{	int8u i;
	for(i=10;i>0;i--)
	{	delay_100us();
	}
}
//***********************************************************************/
void delay_ms (int16u n)
{	int16u i;
	
	
	for(i=n;i>0;i--)
	{	delay_ms_();
	}
}
 #if 1
void delay_cyc (int16u n)
{	
	while(n--);
}
#endif
//***********************************************************************/

//*********************************************************************/




void delay500us(void)   //误差 0us 400us+
{
    unsigned char a,b;
    for(b=111;b>0;b--)
        for(a=10;a>0;a--);
}

#if 1
void delayxus(void)   //  40,3--60us
{
	unsigned char a;
	for(a=45;a>0;a--);
}
#endif




